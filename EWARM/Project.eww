<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CH-53K_LED_Controller.ewp</path>
    </project>
    <batchBuild />
</workspace>
