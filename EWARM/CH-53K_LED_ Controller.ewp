# IAR project CH-53K_LED_ Controller.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303x8; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -s
  OBJCOPY.OOCOutputFile: CH-53K_LED_ Controller.hex
  ILINK.IlinkOutputFile: CH-53K_LED_ Controller.out
  ILINK.IlinkIcfFile: stm32f303x8_flash.icf
  ILINK.IlinkExtraOptions: --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group Application/EWARM
    ./: startup_stm32f303x8.s
  group Application/User/Core
    ../Core/Src/: bsp.c button_handler.c current_handler.c delay_handler.c gpio.c logger.c main.c my_printf.c pwm_handler.c stm32f3xx_it.c thermistor_handler.c tim.c usart.c voltage_handler.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
