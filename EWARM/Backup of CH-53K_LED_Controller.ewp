# IAR project Backup of CH-53K_LED_Controller.ewp, settings and files
configuration CH-53K_LED_Controller (ARM, debug)
  General.OGChipSelectEditMenu: STM32L412KB ST STM32L412KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=8000000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32L412xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CH-53K_LED_Controller.hex
  ILINK.IlinkOutputFile: CH-53K_LED_Controller.out
  ILINK.IlinkIcfFile: stm32l412xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l412xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_tim.c stm32l4xx_ll_dma.c stm32l4xx_ll_usart.c stm32l4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
